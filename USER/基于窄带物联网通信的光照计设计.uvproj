# Keil uVision project 基于窄带物联网通信的光照计设计.uvproj, settings and files
target 程序源码 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 基于窄带物联网通信的光照计设计 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CORE
  group USER
    ./: STARTUP.A51 STC12C5A60S2.h
    ../CORE/: LMS.c
  group CORE
    ../CORE/: main.c 12864.c delay.c Illumination.c UART.c RhAndTemp.c
